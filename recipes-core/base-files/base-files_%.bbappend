# The % wildcard matches any version of base-files
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Override hostname
hostname = "rini-embedded"
